# Keil uVision project audio_config.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x10000000,0x00001000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: audio_config
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\STM32CubeMX\Target_1\user\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Source Group 1
    ./STM32CubeMX/Target_1/user/Inc/: driver_status.h eeprom.h fpga_protocol.h i2c.h platform_time.h uart.h
    ./STM32CubeMX/Target_1/user/Src/: eeprom.c fpga_protocol.c i2c.c platform_time.c uart.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c system_stm32f3xx.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f303x8.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c
software components: CMSIS:CORE 6.1.1, Device:CubeMX 1.0.0
